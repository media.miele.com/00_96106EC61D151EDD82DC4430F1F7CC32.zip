Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-07-20T15:08:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 20 15:08:56 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\84402f01-6445-45ba-a5b6-ebc3f061764d\5bbeaeb6-94a8-4596-95db-6ea6e571880d\ifc * Database version: 5507 * Database creation date: Wed Jul 20 15:08:54 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 20 15:08:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 20 15:08:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11821020_TR_DGC7450_EDST-CLST:22745042_TR_11821020_DGC7450_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22745042_TR_11821020_DGC7450_EDST-CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22745042_TR_11821020_DGC7450_EDST-CLST
Type - Pset_ProvisionForVoid - Depth: 569 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, Default, z_Miele_Design_OBSW, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353828
Description: Flow; FlowDirection: SOURCEANDSINK
